# Allegro board AD-APARDPFW-SL RevB Allegro Project File.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
LT4256_UV on BOTTOM: 27.6,36.42 27.6,29.17 24.14,29.17 24.14,30.59 26.3,30.59 26.3,37.73 29.29,37.73 29.29,36.42
LT4256_UV_ISO on BOTTOM: 42.93,29.1 42.93,28.19 40.12,28.19 40.12,29.1
LTC_GATE on BOTTOM: 25.1,13.8 25.1,12.8 22.6,12.8 22.6,13.7 23.8,13.7 23.8,13.8
LTC_OUT on BOTTOM (solid shape): 32.26,48.02 29.71,48.02 29.71,50.77 32.26,50.77
LTC_OUT on TOP: 52.9,18.75 52.9,13.69 49.94,13.69 49.94,10.15 52.73,10.15 52.73,9.8 54.4,9.8 54.4,16.1 58.3,16.1 58.3,18.75
LTC_OUT on BOTTOM: 32.31,50.78 32.31,43.5 27.69,43.5 27.21,42.94 26.23,42.94 26.23,40.65 25.15,40.65 25.15,43.36 26.12,43.6 26.12,46.55 29.67,46.55 29.67,50.78
LTC_OUT on BOTTOM: 49.66,12.14 49.66,11.19 52.15,11.19 52.15,10.06 54.48,10.06 54.48,12.14
LTC_OUT on BOTTOM: 25.4,13.8 25.4,12.7 28.6,12.7 28.6,12.9 38.59,12.9 38.59,14.5 27.8,14.5 27.8,13.8
LTC_OUT on BOTTOM: 42.54,7.44 42.54,3.9 45.19,3.9 45.19,9.41 42.19,9.41 42.19,7.44
LTC_OUT on BOTTOM: 29.3,35.2 29.3,32.5 27.9,32.5 27.9,35.2
LTC_OUT on L2_PWR: 35.75,14.57 35.75,3.9 49.44,3.9 49.44,9.77 54.44,9.77 54.44,14.57
LTC_OUT on L2_PWR: 38.78,12.99 38.78,14.5 36.01,17.27 29.06,17.27 29.06,31.9 29.06,32.24 29.06,36.17 29.13,36.17 28.23,37.07 28.23,42.68 28.24,42.7 28.24,45.63 25.94,45.63 25.94,15.06 33.72,15.06 35.79,12.99
P1_TXN on TOP: 28.47,25 28.47,24.41 25.55,21.49 25.55,19.99 25.96,19.99 25.96,21.36 28.27,23.67 33.92,23.67 33.92,25
P1_TXP on TOP: 28.5,21.7 33.92,21.7 33.92,23.01 28.5,23.01 28.5,23.01 28.04,23.01 26.21,21.18 26.21,19.99 26.59,19.99 26.59,21.03 28.09,22.53 28.27,22.53 28.5,22.3
P2_TXN on TOP: 29.51,32.72 29.51,33.35 33.92,33.35 33.92,32.01 29.29,32.01 25.96,28.68 25.96,26.47 25.55,26.47 25.55,28.75
P2_TXP on TOP: 29.39,29.71 29.39,30.61 29.16,30.84 28.96,30.84 26.62,28.5 26.62,26.47 26.21,26.47 26.21,28.55 29.39,31.72 33.92,31.72 33.92,29.71
POWER_AND_DATA_N1 on TOP: 26.75,6.38 26.75,4.57 28.02,4.57 28.02,7.14 27.36,7.8 18.59,7.8 16.69,9.7 16.69,14.66 17.83,15.8 18.87,15.8 18.87,17.3 16.26,17.3 14.76,15.8 14.76,9.68 17.78,6.65 26.47,6.65
POWER_AND_DATA_N1 on TOP: 21.8,20.6 21.8,22.55 16.35,22.55 16.35,20.6
POWER_AND_DATA_N1 on L2_PWR: 17.6,15.8 17.6,22.55 15.8,22.55 15.8,15.8
POWER_AND_DATA_N2 on TOP: 23.15,37.4 23.15,34.37 26.95,34.37 26.95,37.6 29.92,37.6 29.92,40.16 26.9,40.16 26.9,39.2 14.65,39.2 14.65,33.65 16.1,33.65 16.1,37.4
POWER_AND_DATA_P1 on TOP: 26.8,12.34 28.02,12.34 28.02,15.39 26.42,16.99 21.44,16.99 18.87,19.56 16.46,19.56 15.95,20.07 15.95,23.27 15.93,23.29 14.86,23.29 14.86,19.66 16.1,18.41 18.72,18.41 21.44,15.7 25.7,15.7 26.8,14.61
POWER_AND_DATA_P2 on TOP: 16.85,35.3 16.85,33.8 21.9,33.8 21.9,35.3
POWER_AND_DATA_P2 on TOP: 14.7,45.16 14.7,39.6 26.42,39.6 26.42,45.45 29.95,45.45 29.95,48 24.82,48 24.82,41.85 16.1,41.85 16.1,45.16
POWER_AND_DATA_P2 on L2_PWR: 17.6,33.78 17.6,41.8 16.06,41.8 16.06,33.78
POWER_N on TOP: 28.83,14.81 28.83,12.29 31.01,10.11 32.18,10.11 32.18,11.86 30.07,13.97 30.07,14.81
POWER_N on BOTTOM: 17.9,14.7 17.9,13.3 14.4,13.3 14.4,10.3 12.9,10.3 12.9,14.7
POWER_N on L2_PWR: 12.9,13.39 12.9,10.3 14.4,10.3 14.4,12.21 28.66,12.21 30.73,10.14 32.34,10.14 32.34,11.76 30.71,13.39
POWER_P on TOP: 32.28,9.55 32.28,6.45 30.38,4.55 28.8,4.55 28.8,6.88 30.94,9.02 30.94,9.55
POWER_P on BOTTOM: 18,19.4 18,18 12.9,18 12.9,19.4
POWER_P on L2_PWR: 12.93,19.38 12.93,13.64 30.92,13.64 32.65,11.91 32.65,9.52 30.67,9.52 30.67,7.64 34.15,7.64 34.15,12.45 31.81,14.78 15.16,14.78 14.42,15.53 14.42,15.53 14.42,19.38
PWRGD_ISO on BOTTOM: 41,22.5 41,21.1 37.9,21.1 37.9,23.2 39.7,23.2 39.7,22.5
STBY on BOTTOM: 26.11,1.45 24.1,1.45 24.1,2.7 25.3,3.9 25.3,6.15 25.5,6.35 25.5,7.5 25.8,7.5 25.8,5.92 26.11,5.61
TC on BOTTOM: 43.37,14.7 43.37,13.7 46.73,13.7 46.73,14.7

## Text on the board
Ref Des/Silkscreen Bottom: X | CLASS 10 | CLASS 11 | CLASS 12 | CLASS 13 | CLASS 14 | JP2 | 1-2 | 2-3 | JP1 | 08-084859 REV B | SECONDARY SIDE | +
User.Comments: 5.    3-PIN JUMPER JP2 MUST BE SHORTED BY DEFAULT AT PIN2 AND PIN3 | 4.    3-PIN JUMPERS JP1, JP3, AND JP4 MUST BE SHORTED BY DEFAULT AT PIN1 AND PIN2 | 6.    2-PIN JUMPER P11 MUST BE SHORTED BY DEFAULT
Ref Des/Assembly Top: +
Ref Des/Silkscreen Top: O | X | JP3 | 1-2 | 2-3 | P9 | P10 | AD | OA | SPI | 1.1V | 1.1/2.4V | Port1P-P | Port2P-P | JP4 | P11 | ENABLE | DISABLE | PORT1SWPD | PORT2SWPD | 1 | 08-084859 REV B | OUTPUT | INPUT | AD-APARDPFWD-SL | EVALUATION BOARD Z | PRIMARY SIDE | +
DIMENSION: DIA MAX/NOTE 29
PAGE_OUTLINE: EVALUATION BOARD Z
User.10: L2_PWR | 08-      -07
User.11: L3_GND | 08-      -08
User.12: FAB NOTES REVISION: NOVEMBER 21 2022 | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | (X) WHITE | ( ) OTHER | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X)  ISOLA 370HR OR S1000-2 OR IT180 OR EQUIVALENT | ( )  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | ( ) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | ( ) GREEN | (X) OTHER BLUE | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.00003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 25. PANELIZATION: | 27.  MINIMUM DESIGN LINE WIDTH IS 0.170 MM. | 28.  MINIMUM DESIGN LINE SPACING IS 0.127 MM. | 29.  SOLDERMASK PLUG ALL 0.254MM DRILLED VIAS. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | ( )  NON-CONDUCTIVE EPOXY FILL ALL 0.XXXX INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | ( ) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED IN ARRAY AND KEPT INTACT | PANEL TO BE SUBJECTED TO CUSTOMERS APPROVAL | PANEL SOLDER PASTE STENCIL GERBER TO BE PROVIDED TO ANALOG | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | TOP | LAYER2 | LAYER3 | LAYER | - | TRACE WIDTH | 50 OHM | IMPEDANCE TABLE | IMPEDANCE TOLERANCE: +/-10% (MILLIMETERS) | 65 OHM | TRACE WIDTH/SPACE | 100 OHM | 0.17/0.127 | 75 OHM | BOTTOM | NOTES: | TOOLING: | FINISH: | MATERIAL: | TESTING: | MISCELLANEOUS:
User.31: PER ECR-094468 | B | 28MAY20 | PD
User.33: PAGE 1 OF 5 | TOP SIDE VIEW | VIEW OF SILKSCREEN, PINS, VIAS, | ETCH AND REFERENCE INFORMATION. | TEMPLATE NOTES. | 01.COMPONENTS ARE PLACED ON THIS SIDE. | 02.CONNECTORS P1,P2.P4 & P5 ARE PLACED | ON THIS SIDE OF THE BOARD. | 03.IF THE BOARD NEEDS TO BE INCREASED | IT CAN BE INCREASED IN THE DIRECTION | OF THE ARROWS. | 04.THE BOARD IS SET-UP AS A 4 LAYER | BOARD. MAKE SURE ANY SUBSEQUENT CHANGES, | MANUAL OR AUTOMATIC, DO NOT RESULT IN | ANY UNINTENDED CONSEQUENCES. | 05.THE EXISTING ROUTING CAN BE ALTERED AS | IS ROUTED TO CLOSE THE NETS ON THE | TEMPLATE BOARD.
User.34: PAGE 2 OF 5 | BOTTTOM SIDE VIEW | VIEW OF SILKSCREEN, PINS, VIAS, | ETCH AND REFERENCE INFORMATION. | TEMPLATE NOTES. | 01.COMPONENTS ARE PLACED ON THIS SIDE. | 02.CONNECTORS P3 IS PLACED ON THIS SIDE. THE | OTHER CONNECTORS ARE SOLDERED THIS SIDE. | 03.THE TEMPLATE IS VIEWED LOOKING FROM THE | TOP SIDE OF THE BOARD. THE RESULT IS | THAT TEXT IS MIRRORED. | 04.THE BOARD IS SET-UP AS A 4 LAYER | BOARD. MAKE SURE ANY SUBSEQUENT CHANGES, | MANUAL OR AUTOMATIC, DO NOT RESULT IN | ANY UNINTENDED CONSEQUENCES.
User.35: PAGE 3 OF 5 | PCB FAB SHEET 1 | NCDRILL LEGEND, APPROPRIATE | DETAILS AND OUTLINE DIMENSION NOTES. | 01. EACH TIME THE NC DRILL LEGEND | IS RUN, THE HOLE CHART MUST BE | CHECKED TO ASSURE THE TOLERANCES | & NOTES CORRESPOND TO THE RIGHT | PADSTACKS.
User.36: PAGE 4 OF 5 | PCB FAB SHEET 2 | FABRICATION NOTES. ALTER DEPENDING ON THE | REQUIREMENTS OF THE DESIGN.
User.37: TEMPLATE REVISION HISTORY | TEMPLATE BOARDS FOR EVAL PROVIDE INFORMATION IN THE | 5-VIEW "PDF FORMAT" FOR EVAL ENGINEERING | REFERENCE; ALONG WITH EMBEDDED ALLEGRO | PROPERTIES FOR PCB DESIGN USE. | THEY MAINTAIN A SEPARATE TITLE BLOCK AND PART | NUMBER FOR REVISION TRACKING, INDEPENDENT OF | THE ACTUAL MANUFACTURED DUT-SPECIFIC BOARD | DESIGN. | TEMPLATE BOARDS DISPLAY AS "FILE VIEWS", AND | DUT-SPECIFIC APPLICATION BOARDS ARE | MANUFACTURED FROM ARTWORK "FILM VIEWS"AND NC | DATA. | AND TITLE BLOCK CONTENT IS TRACKING THE | MANUFACTURED BOARD PART NUMBER AND REV, | AND NOT THE TEMPLATE BOARD PART NUMBER AND | REV. | PAGE 5 OF 5 | MAKE SURE THE DUT-SPECIFIC BOARD INFORMATION | REV.A (20APR20) | 1. INITIAL RELEASE. | REV.B (28MAY20) PER ECR-094468 | 1. BRING FILES INTO TEMPLATE FORMAT.
User.43: 1 | FABRICATION | 09-012345-01 | A
User.44: FIGURE | SIZE | 0.254 | 1.143 | 1.397 | 3.175 | DRILL CHART: TOP to BOTTOM | FINISHED HOLES IN MILLIMETERS | PLATED | NON-PLATED | QTY | 512 | 50 | 6 | 2 | 570 | TOLERANCE/NOTES | TOTAL HOLES:
